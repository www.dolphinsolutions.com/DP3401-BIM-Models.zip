Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2024-03-19T08:51:46
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20200210_1400(x64) - Exporter 20.2.12.1 - Alternate UI 20.2.12.1
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Mar 19 08:51:46 2024 * Host: Yogoon * Database: C:\Users\gokul\AppData\Local\Temp\2e13ad9b-9c38-4c71-93a6-3bb9e012d381\f6d101e7-e346-4af5-b911-1cf35dcec769\ifc * Database version: 5507 * Database creation date: Tue Mar 19 08:51:46 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Mar 19 08:51:46 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Mar 19 08:51:46 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcBuildingElementProxy: DP3401, DP3401:DP3401:348667
In: Level 1
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Depth: 120 mm; Height: 148 mm; Width: 298 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_40_70_22_62 Paper towel dispensers; CAWS: N13/442 Paper towel dispensers; CodePerformance: n/a; Color: various; Constituents: n/a; Description: FreeStandingPaperTowelDispenser; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Finish: Brushed Satin_Powder Coated_Ceramic Coated; Form: FreeStanding; Grade: 304; InstallationDate: 31-12-1900 23:59; Manufacturer: info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: www.dolphinsolutions.co.uk; Material: StainlessSteel; ModelNumber: DP3401; ModelReference: DolphinSolutionsLimited_FreeStandingPaperTowelDispenser; Name: FreeStandingPaperTowelDispenser_DolphinSolutionsLimited; NBSDescription: Paper towel dispensers; NBSTypeID: n/a; NominalDepth: 120; NominalHeight: 148; NominalLength: 298; ObjectClassification: 23.40.20.21.17; ProductInformation: https://www.dolphinsolutions.co.uk/product/dolphin-paper-towel-dispenser-2/; ReplacementCost: n/a; Revision: n/a; SerialNumber: n/a; Shape: Rectangular; Size: 148 x 298 x 120 mm; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: DP3401; Uniclass2015Code: Pr_40_70_22_62; Uniclass2015Title: Paper towel dispensers; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a; WarrantyStartDate: 31-12-1900 23:59
Type - Other - Category: Generic Models; Family Name: DP3401
Type - Pset_BuildingElementProxyCommon - Reference: DP3401:DP3401
Type - Pset_ElementShading - Color: various
Type - Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: DolphinSolutionsLimited_FreeStandingPaperTowelDispenser; Manufacturer: info@dolphinsolutions.co.uk
Type - Pset_PrecastConcreteElementGeneral - SerialNumber: n/a
Type - Pset_ProductRequirements - Name: FreeStandingPaperTowelDispenser_DolphinSolutionsLimited; Category: Pr_40_70_22_62 Paper towel dispensers
Type - Pset_QuantityTakeOff - Reference: DP3401:DP3401
Pset_BuildingElementProxyCommon - sets with these values: 2
Pset_ProductRequirements - Category: Generic Models
Constraints - Elevation from Level: 0 mm; Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset from Host: 0 mm
Dimensions - Area: 0.139621 m2; Volume: 0.000277343 m3
Other - Family: DP3401: DP3401; Family and Type: DP3401: DP3401; Type: DP3401: DP3401; Type Id: DP3401: DP3401
Phasing - Phase Created: New Construction
